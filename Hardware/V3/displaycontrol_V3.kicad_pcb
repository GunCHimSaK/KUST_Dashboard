# Repository GunCHimSaK/KUST_Dashboard

File README.md:

# KUST Dashboard Control Board

태양광 자동차 동아리 **KUST**의 2027 World Solar Challenge(WSC) 출전 차량에 들어가는 **계기판(디스플레이) 컨트롤 보드**입니다.
차량 CAN 버스에서 주행·배터리 데이터를 받아 운전자 앞 LCD에 표시하고, 핸들 버튼 입력을 CAN으로 다른 보드에 전달합니다.

회로 설계, 부품 선정, 4층 PCB 아트웍, 보드 검증, 펌웨어까지 **혼자 설계·제작**했습니다.

## 주요 사양 (V3)

| 항목 | 내용 |
|---|---|
| 입력 전원 | 차량 12V LV 라인 (XT30) |
| 소비 전류 | **약 0.4 mA @ 12V** (실측) |
| 전원 보호 | LM76202-Q1 차량용 eFuse: 역극성 −60V, UVLO 9V, OVP 16V, 전류 제한 1.2A / SMBJ24CA TVS |
| 전원 변환 | LT8640S 동기 벅 12V→5V (2MHz) → LT1963A LDO 5V→3.3V |
| MCU | STM32U545CET6Q (Cortex-M33 저전력, 내부 SMPS 사용) |
| 디스플레이 | Sharp Memory-in-Pixel LCD (SPI, 10핀 FPC) |
| 통신 | CAN 2.0 500 kbit/s (TJA1051T/3), 디버그 UART |
| 입력 | 핸들 버튼 5채널, 포토커플러 절연 디지털 입력 4채널 (TLP291-4) |
| PCB | 4층, 80 × 50 mm, KiCad, JLCPCB 제작 |
| 장착 위치 | 핸들 뒷면 |

## 시스템 구성

```
 차량 12V ──▶ [TVS] ─▶ [eFuse LM76202-Q1] ─▶ [LT8640S 12→5V] ─▶ [LT1963A 5→3.3V] ─▶ MCU / CAN / LCD
                        역극성·UVLO·OVP·과전류      2MHz 동기 벅          저노이즈 LDO
                        FAULT LED, IMON

 차량 CAN 버스 ◀──▶ [NUP2105L ESD] ◀──▶ [TJA1051T/3] ◀──▶ STM32U545 ──SPI──▶ Sharp Memory LCD
 핸들 버튼 5ch ──▶ [ESD 어레이] ──────────────────────────▶ STM32U545 (EXTI)
 외부 디지털 입력 4ch ──▶ [TLP291-4 포토커플러] ─────────────▶ STM32U545
```

### 펌웨어 데이터 흐름

### 계기판 화면 (SquareLine Studio)

방향지시등·비상등·경고, 속도, ACC 설정 속도, 권장 속도, 모터·MPPT 전력, 통신 상태, 시간, 배터리 잔량(SOC)을 표시합니다. 왼쪽은 모든 표시를 켠 상태, 오른쪽은 일반 주행 상태입니다.

## 하드웨어 설계

### 1. 전원 보호부 — LM76202-Q1

차량 LV 라인은 배선 실수(역극성), 부하 변동, 서지에 노출됩니다. 보호 소자를 따로 여러 개 두는 대신, 역극성 보호용 back-to-back MOSFET이 내장된 **AEC-Q100 eFuse(LM76202-Q1)** 하나로 보호 기능을 묶었습니다.

| 기능 | 설정 | 근거 |
|---|---|---|
| 저전압 차단(UVLO) | 9 V | 분압 44.2k / 2.43k / 3.74k → UVLO 핀 1.102 V (기준 1.1 V) |
| 과전압 차단(OVP) | 16 V | 같은 분압 → OVP 핀 1.188 V (기준 1.19 V) |
| 전류 제한 | 1.2 A | I_LIM = 12 / R(kΩ), R = 10 kΩ |
| 돌입 전류 제어 | 약 20.9 ms 상승 | dV/dt 커패시터 100 nF |
| 고장 동작 | Circuit breaker (latch-off) | 0 Ω으로 바꾸면 auto-retry |
| 상태 표시 | FAULT LED, IMON 전류 모니터 출력 | IMON은 ADC(PB1)로 연결 |

- 입력단에 **SMBJ24CA 양방향 TVS**를 두어 eFuse가 감당하기 전의 순간 서지를 클램프합니다.
- 회로도에 계산 과정과 근거를 메모로 남겨 두어, 후배가 저항값을 바꿀 때 바로 따라갈 수 있게 했습니다.

### 2. 전원 변환부 — LT8640S + LT1963A

- **LT8640S (42V, Silent Switcher 2)**: 내부 바이패스 커패시터로 스위칭 노이즈가 작은 동기 벅입니다. 계기판 바로 옆에 CAN·LCD 신호가 지나가서 EMI가 적은 부품을 골랐습니다.
  - 출력: V_OUT = 0.97 V × (1 + 1 MΩ / 243 kΩ) ≈ **4.96 V**
  - 스위칭 주파수: R_T = 17.8 kΩ → **2 MHz** (AM 방송 대역 위쪽이고, 인덕터를 1.5 µH 소형으로 쓸 수 있음)
  - 입력단 페라이트 비드 + 10 µF ×2, 1 µF ×2 로 입력 리플이 12V 라인으로 돌아가지 않게 했습니다.
- **LT1963A-3.3 LDO**: 벅 출력의 리플을 한 번 더 걸러 MCU, CAN 트랜시버, LCD에 깨끗한 3.3V를 공급합니다.

### 3. MCU — STM32U545

- 태양광 차량이라 전력 예산이 빠듯해서 **저전력 STM32U5 시리즈**를 선택했고, 내부 **SMPS(2.2 µH)** 를 사용해 코어 전원 효율을 높였습니다.
- 16 MHz 외부 수정 발진기(HSE)로 CAN 비트 타이밍을 안정적으로 맞췄습니다 (16 MHz / 32 tq = 500 kbit/s).
- 디스플레이 전원(5VA)은 **페라이트 비드로 분리**하고, 아날로그 GND(GNDA)는 0 Ω 저항 한 점으로만 디지털 GND와 연결했습니다.
- SWD 디버그 라인에는 직렬 47 Ω과 ESD 어레이, 리셋 버튼에는 ESD 다이오드를 넣었습니다.

| 기능 | 핀 |
|---|---|
| 핸들 버튼 0~4 | PA0~PA4 (EXTI) |
| LCD SPI (SCK / MOSI / SCS) | PA5 / PA7 / PA6 |
| LCD EXTCOMIN | PB0 (TIM3_CH3) |
| IMON (전류 모니터) | PB1 (ADC1_IN16) |
| 디지털 입력 0~3 | PA8, PB15, PB14, PB13 |
| CAN | PA11 RX / PA12 TX (FDCAN1, Classic CAN) |
| 디버그 UART | PA9 / PA10 (USART1) |

### 4. CAN 인터페이스

- **TJA1051T/3**: VIO 핀으로 3.3V MCU와 직접 연결되는 CAN 트랜시버.
- **Split termination**: 60.4 Ω × 2 + 4.7 nF로 공통 모드 노이즈를 GND로 빼서 EMI를 줄였습니다.
- **NUP2105L**: CAN 전용 ESD 보호 다이오드를 커넥터 가까이 배치.

### 5. PCB 아트웍 (4층, 80 × 50 mm)

| 전체 레이어 | Bottom |
|---|---|
|  |  |
| **In1** | **In2** |
|  |  |

- 핸들 뒷면에 붙이기 위해 V2보다 크기를 줄이고, 커넥터를 보드 가장자리로 모아 배선이 핸들 안쪽으로 빠지게 했습니다.
- 전원부(eFuse, 벅, LDO)를 보드 왼쪽 위에 몰아 스위칭 루프를 짧게 하고, CAN·LCD·MCU와 거리를 두었습니다.
- 내층을 GND 플레인으로 써서 신호의 귀환 경로를 확보하고, eFuse의 RTN(역극성 보호 기준)은 GND와 따로 영역을 나눴습니다.
- eFuse·벅 아래에 비아를 여러 개 두어 열을 내층과 아랫면으로 퍼뜨렸습니다.

## 버전 이력

| 버전 | 시기 | 내용 |
|---|---|---|
| V1 | 2026 초 | 만능기판 프로토타입. Sharp LCD 구동과 UI 확인 |
| V2 | 2026.03 ~ 04 | 첫 PCB (STM32U535). 보드 안에 컨버터 없이 외부 전원 사용 (`Hardware/V2`) |
| **V3** | 2026.07 ~ 08 | 전원 보호부(eFuse)와 12V→5V→3.3V 컨버터를 보드에 통합. 팀 요구에 맞춰 통신·입력 커넥터 재구성, 핸들 뒷면 장착을 위해 소형화 (`Hardware/V3`) |

## 검증

PCB를 받은 뒤 감에 의존하지 않고 아래 순서로 한 단계씩 확인했습니다.

| 단계 | 내용 | 결과 |
|---|---|---|
| 1. 외관·단락 점검 | 납땜 상태, 전원–GND 저항 측정 | (사진 추가 예정) |
| 2. 전원부 단독 확인 | 12V 인가 후 5V, 3.3V 출력 측정 | ✅ 아래 사진 |
| 3. MCU 부팅 | SWD 연결, 펌웨어 업로드 | (사진 추가 예정) |
| 4. 통신·표시 | CAN 송수신, LCD 표시 | ✅ 계기판 동작 화면 |

### 2. 전원부 출력 측정

파워 서플라이로 12V를 인가하고 멀티미터로 LDO 출력(3.3V)과 벅 출력(5V)을 측정했습니다.

| 측정 항목 | 설계값 | 측정값 |
|---|---|---|
| 12V 입력 소비 전류 | - | 약 0.4 mA |
| 벅 출력 (5V) | 4.96 V | 약 4.9 V |
| LDO 출력 (3.3V) | 3.3 V | 3.35 V |

### 추가 예정
- [ ] 외관·단락 점검 사진
- [ ] 오실로스코프: 벅 출력 리플, 스위칭 노드 파형
- [ ] 오실로스코프: CANH / CANL 파형
- [ ] 소비 전류 측정 사진
- [ ] 차량(핸들) 장착 사진

## 펌웨어 (`Firmware/`)

STM32CubeIDE + HAL, UI는 LVGL 8.3 + SquareLine Studio로 만들었습니다. 펌웨어는 하드웨어를 검증하고 차량에서 쓰기 위한 최소 기능 위주입니다.

| 모듈 | 역할 |
|---|---|
| `can_bus.c` | FDCAN 초기화, 수신 인터럽트, bus-off 감지 후 200 ms마다 재시도 |
| `can_app.c` | 주행 데이터(0x501) 해석, 600 ms 무수신 시 끊김 판정, ACC 명령(0x510) 200 ms 주기 송신 |
| `can_text.c` | 지상국 텍스트 메시지(0x500) 여러 프레임 조립 |
| `SHARP_MIP.c` | Sharp Memory LCD SPI 드라이버 |
| `dashboard_ui.c` | 속도, SOC, 전력, 경고 표시 |
| `imon.c` | eFuse IMON 전류 ADC 측정 (직렬 100 kΩ 때문에 샘플링 시간 814.5 cycle) |
| `debug_log.c` | 디버그 로그, 수신 주기·지터 통계, 시험용 CAN 프레임 주입 |

### CAN 메시지 (500 kbit/s, 표준 11bit ID)

| ID | 방향 | 주기 | 내용 |
|---|---|---|---|
| 0x500 | 통신보드 → 계기판 | 이벤트 | 텍스트 메시지 (byte0 = 마지막 플래그 + 시퀀스, byte1~7 = 본문) |
| 0x501 | 통신보드 → 계기판 | 200 ms | 속도(0.01 m/s), 전류(0.1 A), SOC(0.1 %), 전력(1 W), 각 2바이트 리틀엔디안 |
| 0x510 | 계기판 → 통신보드 | 200 ms | byte0 = ACC 설정 속도(km/h), byte1 = ACC on/off |

## 폴더 구조

```
├── Hardware/
│   ├── V3/          최신 보드 (KiCad 회로도·PCB, STEP, BOM, 거버)
│   └── V2/          이전 보드
├── Firmware/        STM32CubeIDE 프로젝트 (STM32U545)
└── docs/images/     회로도, 아트웍, 실물 사진
```

## 사용 도구
KiCad · STM32CubeIDE / CubeMX · LVGL · SquareLine Studio · 멀티미터 · 오실로스코프

## KiCad design Hardware/V3/displaycontrol_V3.kicad_pcb

Parts:
C1: 10p/0603; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder; LCSC C1634
C2, C3: 10uF/0805; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder; LCSC C15850
C4, C5: 1uF/0603; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder; LCSC C15849
C6, C7: 22uF/0805; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder; LCSC C45783
C8, C9: 10uF/0603; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder; LCSC C15850
FB1: FerriteBead; BLM18SP221SN1B; LCSC C3764477
L1: 1.5uH; IND_XFL4020-152MEC; LCSC C3033018
R1: 1M/0603; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; LCSC C22935
R2: 243k/0603; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; LCSC C137764
R3: 17.8k/0603; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; LCSC C185364
U1: LT8640SEV_PBF; CONV_LT8640SEV_PBF; PARTREV NA; LCSC C514429
U2: LT1963AEST-3.3#TRPBF; SOT-223-3_TabPin2; LCSC C459918

Connections:
+3V3: C9.1, U2.3 (OUT); also elsewhere on the board
+5V: C1.2, C6.1, C7.1, C8.1, L1.2, R1.1, U1.1 (BIAS), U2.1 (IN); also elsewhere on the board
+12V: C2.1, FB1.1; also elsewhere on the board
GND: C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, R2.2, R3.2, U1.3 (GND), U1.16 (GND), U1.22 (GND), U1.25 (GND), U1.26 (GND), U1.27 (GND), U1.28 (GND), U2.2 (GND); also elsewhere on the board
unnamed: L1.1, U1.8 (SW), U1.9 (SW), U1.10 (SW), U1.11 (SW), U1.12 (SW)
unnamed: C3.1, C4.1, C5.1, FB1.2, U1.5 (VIN), U1.6 (VIN), U1.13 (VIN), U1.14 (VIN), U1.17 (EN)
unnamed: C1.1, R1.2, R2.1, U1.24 (FB)
unnamed: U1.2 (INTVCC), U1.20 (SYNC/MODE)
unnamed: R3.1, U1.18 (RT)

Notes on the sheet:
Max current: 1.5A
fsw = 2MHz
5 to 3.3 LDO
PowerProtection
12 to 5 Converter

Parts:
C15, C16, C17, C21, C26, C28, C29, C34, C35, C37, C38, C39: 100nF/0603; C_0603_1608Metric; Manufacturer_Part_Number GCM188R71C104KA37D; LCSC C14663
C18: 4.7nF/0603; C_0603_1608Metric; Manufacturer_Part_Number GCM1885C1H472JA16D; LCSC C53987
C19, C20, C24, C25: 1uF/0603; C_0603_1608Metric; Manufacturer_Part_Number GCM188R71C104KA37D; LCSC C15849
C22, C23: 8.2pF/0603; C_0603_1608Metric; Manufacturer_Part_Number GCM1885C2A8R2BA16D; LCSC C1685
C27, C40: 10uF/0805; C_0805_2012Metric; Manufacturer_Part_Number GCM21BC71C106KE36K; LCSC C15850
C30, C31: 2.2uF/0805; C_0805_2012Metric; Manufacturer_Part_Number GCM21BR71C225KA64L; LCSC C377773
C32, C36, C41: 1uF/0603; C_0603_1608Metric; Manufacturer_Part_Number GCM188R71E105KA64D; LCSC C15849
C33: 1uF/0805; C_0805_2012Metric; Manufacturer_Part_Number GCM21BR71E105KA56L; LCSC C28323
CR1: ESDALC6V1W5; SOT65P210X110-5N; Manufacturer_Part_Number ESDALC6V1W5; LCSC C703691
D3: NUP2105L; SOT-23; LCSC C233494
D5: LED1; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder; LCSC C2286
D6: ESDA6V1-5SC6; SOT-23-6; LCSC C6650
D7, D8, D9, D10: 1N4148WS; D_SOD-323; LCSC C2128
D11: PESD5V0U1UA,115; D_SOD-323; LCSC C139614
FB2: BLM18PG600SN1D; BLM18SP221SN1B; Mouser Part Number 81-BLM11P600S
J1: STLINK; 20037WR-05; Manufacturer_Part_Number 20037WR-05A00; not fitted
J3: XT30UPB-M; AMASS_XT30UPB-M; LCSC C428721; not fitted
J4: FH34SRJ-10S-0.5SH_50_; HRS_FH34SRJ-10S-0.5SH_50_; PARTREV Apr.1.2022; LCSC C324723
J5: Conn_02x03_Odd_Even; PinHeader_2x03_P2.54mm_Vertical
L2: 2.2uH/0805; L_0805_2012Metric; Manufacturer_Part_Number LQM21PN2R2MGHL; LCSC C341781
R13, R16: 60.4/0603; R_0603_1608Metric; Manufacturer_Part_Number CRCW060360R4FKEAC; LCSC C245987
R14, R30, R31, R35, R36: 10K/0603; R_0603_1608Metric; Manufacturer_Part_Number CRCW060310K0FKEA; LCSC C844918
R15: 120/0603; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; LCSC C22787
R17: 10k/0603; R_0603_1608Metric; Manufacturer_Part_Number CRCW060310K0FKEA; LCSC C844918
R18, R19: 47/0603; R_0603_1608Metric; Manufacturer_Part_Number CRCW060347R0JNEA; LCSC C23182
R20, R21, R22, R26, R27: 4.7K/0603; R_0603_1608Metric; Manufacturer_Part_Number CRCW06034K70FKEA; LCSC C23162
R23, R24, R28, R29: 1k/0603; R_0603_1608Metric; Manufacturer_Part_Number CRCW0603100RFKEA; LCSC C21190
R25: 100/0603; R_0603_1608Metric; Manufacturer_Part_Number CRCW0603100RFKEA; LCSC C22775
R32, R33, R37, R38: 2.2K/0603; R_0603_1608Metric; Manufacturer_Part_Number CRCW06034K70FKEA; LCSC C4190
R34, R39: 0/0603; R_0603_1608Metric; Manufacturer_Part_Number CRCW06030000Z0EA; LCSC C21189
S1: 147873-1; 1478731; Mouser Part Number 506-147873-1
U4: STM32U545CET6Q; LCSC C20033864
U5: TJA1051T-3; SOIC-8_3.9x4.9mm_P1.27mm; Manufacturer_Part_Number TJA1051T/3/1J; LCSC C38695
U6, U8: wr_06p; 20037WR-06; Manufacturer_Part_Number 20037WR-06A00; not fitted
U7: wr_03p; 20037WR-03; Manufacturer_Part_Number 20037WR-03A00; not fitted
U9: TLP291-4GB-TP_E; TLP291-4; LCSC C60900
X1: XS00A-CS07826; PARTREV N/A; LCSC C7322371

Connections:
+3V3: C15.1, C26.1, C27.1, C34.1, C37.1, C38.1, C39.1, C40.1, C41.1, J1.5, J4.6 (DISP), J5.1, R20.2, R21.2, R22.2, R26.2, R27.2, R30.2, R31.2, R34.1, R35.2, R36.2, U4.1 (VBAT), U4.21 (VDDSMPS), U4.25 (VDD), U4.36 (VDD), U4.48 (VDD), U5.5 (VIO); also elsewhere on the board
+5V: C16.2, C32.1, FB2.1, J4.3 (EXTMODE), J4.4 (VDD), J5.2, U5.3 (VCC); also elsewhere on the board
+5VA: C33.1, FB2.2, J4.5 (VDDA)
+12V_EXT: J3.P; also elsewhere on the board
/Converter/IMON_OUT: U4.19 (PB1); also elsewhere on the board
/MCU/CANH: D3.2 (K), R13.2, U5.7 (CANH), U7.3
/MCU/CANL: D3.1 (K), R16.2, U5.6 (CANL), U7.2
/MCU/DIN0: R38.1, U6.6
/MCU/DIN1: R37.1, U6.5
/MCU/DIN2: R33.1, U6.4
/MCU/DIN3: R32.1, U6.3
/MCU/EXTCOMIN: J4.7 (EXTCOMIN), U4.18 (PB0)
/MCU/FDCAN1_RX: U4.32 (PA11), U5.4 (RXD)
/MCU/FDCAN1_TX: U4.33 (PA12), U5.1 (TXD)
/MCU/I2C1_SCL: U4.42 (PB6)
/MCU/I2C1_SDA: U4.43 (PB7)
/MCU/JTCK-SWCLK: R18.2, U4.37 (PA14)
/MCU/JTMS-SWDIO: R19.1, U4.34 (PA13)
/MCU/LED: R15.1, U4.2 (PC13)
/MCU/OSC_IN: C23.1, U4.5 (PH0-OSC_IN), X1.3
/MCU/OSC_OUT: C22.1, U4.6 (PH1-OSC_OUT), X1.1
/MCU/PA15: U4.38 (PA15)
/MCU/PB3: U4.39 (PB3)
/MCU/PB4: U4.40 (PB4)
/MCU/PB5: U4.41 (PB5)
/MCU/PB8: U4.45 (PB8)
/MCU/PC14: U4.3 (PC14-OSC32_IN)
/MCU/PC15: U4.4 (PC15-OSC32_OUT)
/MCU/SCLK: J4.10 (SCLK), U4.15 (PA5)
/MCU/SCS: J4.8 (SCS), U4.16 (PA6)
/MCU/SI: J4.9 (SI), U4.17 (PA7)
/MCU/STM_Button_0: C19.1, R20.1, R23.1, U4.10 (PA0)
/MCU/STM_Button_1: C20.1, R21.1, R24.1, U4.11 (PA1)
/MCU/STM_Button_2: C21.1, R22.1, R25.1, U4.12 (PA2)
/MCU/STM_Button_3: C24.1, R26.1, R28.1, U4.13 (PA3)
/MCU/STM_Button_4: C25.1, R27.1, R29.1, U4.14 (PA4)
/MCU/STM_DIN0: R36.1, U4.29 (PA8), U9.10
/MCU/STM_DIN1: R35.1, U4.28 (PB15), U9.12
/MCU/STM_DIN2: R31.1, U4.27 (PB14), U9.14
/MCU/STM_DIN3: R30.1, U4.26 (PB13), U9.16
/MCU/USART1_RX: J5.3, U4.31 (PA10)
/MCU/USART1_TX: J5.5, U4.30 (PA9)
/MCU/VDD11: C28.2, C29.1, C30.1, C31.1, L2.1, U4.23 (VDD11), U4.46 (VDD11)
/MCU/VDDA: C35.1, C36.1, R34.2, U4.9 (VDDA)
/MCU/VLXSMPS: L2.2, U4.20 (VLXSMPS)
/MCU/button_0: D6.3 (IO2), R23.2, U8.6
/MCU/button_1: D6.4 (IO3), R24.2, U8.5
/MCU/button_2: D6.5 (IO4), R25.2, U8.4
/MCU/button_3: D6.6 (IO5), R28.2, U8.3
/MCU/button_4: D6.1 (IO1), R29.2, U8.2
GND: C15.2, C16.1, C17.2, C18.1, C19.2, C20.2, C21.2, C22.2, C23.2, C24.2, C25.2, C26.2, C27.2, C28.1, C29.2, C30.2, C31.2, C32.2, C34.2, C37.2, C38.2, C39.2, C40.2, C41.2, CR1.2, D3.3 (A), D5.1 (K), D6.2 (GND), D11.2 (A), J1.1, J3.N, J4.2 (VSS), J5.4, J5.6, R14.2, R17.1, R39.1, S1.2, U4.8 (VSSA), U4.22 (VSSSMPS), U4.24 (VSS), U4.35 (VSS), U4.47 (VSS), U5.2 (GND), U7.1, U8.1, U9.9, U9.11, U9.13, U9.15, X1.2 (GND), X1.4 (GND); also elsewhere on the board
GNDA: C33.2, C35.2, C36.2, J4.1 (VSSA), R39.2
GND_EXT: D7.2 (A), D8.2 (A), D9.2 (A), D10.2 (A), U6.1, U6.2, U9.2, U9.4, U9.6, U9.8
unnamed: C18.2, R13.1, R16.1
unnamed: D5.2 (A), R15.2
unnamed: D7.1 (K), R32.2, U9.1
unnamed: D8.1 (K), R33.2, U9.3
unnamed: D9.1 (K), R37.2, U9.5
unnamed: D10.1 (K), R38.2, U9.7
unnamed: CR1.1, J1.2, R19.2
unnamed: CR1.3, J1.3, R18.1
unnamed: R14.1, U4.44 (PH3-BOOT0)
unnamed: R17.2, U5.8 (S)
RESET: C17.1, D11.1 (K), J1.4, S1.1, U4.7 (NRST)

Notes on the sheet:
Digital Input Channels
Data_logger
Display
SIGNAL
Display_VDD
VDD
EXTERNAL HSE CLK
Button
CONNECTORS
POWER
LED
STM32
CAN
RESET FUNCTION
GPIO HEADER
STLINK
SMPS
CAN_Tranciver

Parts:
C10: 10uF/0805/50V; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder; LCSC C440198
C11, C12: 1uF/0603; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder; LCSC C15849
C13: 10uF/0603; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder; LCSC C15850
C14: 100nF/0603; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder; LCSC C14663
D1: SMBJ24CA; DIOM4336X265N; PARTREV I2102; LCSC C83268
D2: PFLT; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder; LCSC C2286
R4: 100k/0603; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; LCSC C25803
R5: 20k/0603; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; LCSC C4184
R6, R8: 10k/0603; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; LCSC C844918
R7: 402k/0603; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; LCSC C227888
R9: 3.3k/0603; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; LCSC C22978
R10: 44.2k/0603; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; LCSC C227499
R11: 2.43k/0603; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; LCSC C227772
R12: 3.74k/0603; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; LCSC C227866
U3: LM76202QPWPRQ1; IC_LM76202QPWPRQ1; LCSC C1849484

Connections:
+12V: C12.1, C13.1, U3.15 (OUT_1), U3.16 (OUT_2); also elsewhere on the board
+12V_EXT: C10.1, C11.1, D1.1, R8.1, R9.1, R10.1, U3.1 (IN_1), U3.2 (IN_2); also elsewhere on the board
/Converter/IMON_OUT: R4.2; also elsewhere on the board
/Converter/PowerProtection/FAULT: D2.1 (K), R8.2, U3.14 (~FLT)
/Converter/PowerProtection/ILIM: R6.1, U3.11 (ILIM)
/Converter/PowerProtection/IMON: R4.1, R5.1, U3.10 (IMON)
/Converter/PowerProtection/MODE: R7.1, U3.6 (MODE)
/Converter/PowerProtection/OVP: R11.2, R12.1, U3.5 (OVP)
/Converter/PowerProtection/RTN: C14.2, R5.2, R6.2, R7.2, R12.2, U3.8 (RTN), U3.17 (EP)
/Converter/PowerProtection/SHDN: U3.7 (~SHDN)
/Converter/PowerProtection/UVLO: R10.2, R11.1, U3.3 (UVLO)
GND: C10.2, C11.2, C12.2, C13.2, D1.2, U3.9 (GND); also elsewhere on the board
unnamed: D2.2 (A), R9.2
unnamed: C14.1, U3.12 (DVDT)

Notes on the sheet:
ILim(A) = 12/R(k) 1.2A = 12/10kΩ
DNP until validated
Power fault LED
Under/Overvoltage Protection
Typical gain: 78.28 uA/A Vout @ 1.5A = 2.231v R(imon) = 19 kΩ
Current Monitoring
20.88 ms ramp time
아직 총전류 계산 못함
RTN!=GND Conecting GND to RTN turns off RPP!
Set to circuit breaker (latchoff) Use 0 ohm resistor for auto-retry (540ms)
Overcurrent Protection
Functional Mode Selection

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
Board: 4 copper layers, 80.0 x 50.0 mm, 110 parts (0 on the bottom side), 70 nets.

File Hardware/V3/production/bom.csv:

Designator,Footprint,Quantity,Value,LCSC Part #
C1,0603,1,10p/0603,C1634 
C10,0805,1,10uF/0805/50V,C440198
"C11, C12, C19, C20, C24, C25, C32, C36, C4, C41, C5",0603,11,1uF/0603,C15849
"C13, C8, C9",0805,3,10uF/0603,C15850
"C14, C15, C16, C17, C21, C26, C28, C29, C34, C35, C37, C38, C39",0603,13,100nF/0603,C14663
C18,0603,1,4.7nF/0603,C53987
"C2, C27, C3, C40",0805,4,10uF/0805,C15850
"C22, C23",0603,2,8.2pF/0603,C1685
"C30, C31",0805,2,2.2uF/0805,C377773
C33,0805,1,1uF/0805,C28323
"C6, C7",0805,2,22uF/0805,C45783
CR1,SOT65P210X110-5N,1,ESDALC6V1W5,C703691
D1,DIOM4336X265N,1,SMBJ24CA,C83268
"D10, D7, D8, D9",D_SOD-323,4,1N4148WS,C2128
D11,D_SOD-323,1,"PESD5V0U1UA,115",C139614
D2,0603,1,PFLT,C2286
D3,SOT-23,1,NUP2105L,C233494
D5,0603,1,LED1,C2286
D6,SOT-23-6,1,ESDA6V1-5SC6,C6650
FB1,BLM18SP221SN1B,1,FerriteBead,C3764477
FB2,BLM18SP221SN1B,1,BLM18PG600SN1D,C3764477
J4,HRS_FH34SRJ-10S-0.5SH_50_,1,FH34SRJ-10S-0.5SH_50_,C324723
L1,IND_XFL4020-152MEC,1,1.5uH,C3033018
L2,0805,1,2.2uH/0805,C341781
R1,0603,1,1M/0603,C22935
R10,0603,1,44.2k/0603,C227499
R11,0603,1,2.43k/0603,C227772
R12,0603,1,3.74k/0603,C227866
"R13, R16",0603,2,60.4/0603,C245987
"R14, R17, R30, R31, R35, R36, R6, R8",0603,8,10K/0603,C844918
R15,0603,1,120/0603,C22787
"R18, R19",0603,2,47/0603,C23182
R2,0603,1,243k/0603,C137764
"R20, R21, R22, R26, R27",0603,5,4.7K/0603,C23162
"R23, R24, R28, R29",0603,4,1k/0603,C21190
R25,0603,1,100/0603,C22775
R3,0603,1,17.8k/0603,C185364
"R32, R33, R37, R38",0603,4,2.2K/0603,C4190
"R34, R39",0603,2,0/0603,C21189
R4,0603,1,100k/0603,C25803
R5,0603,1,20k/0603,C4184
R7,0603,1,402k/0603,C227888
R9,0603,1,3.3k/0603,C22978
S1,1478731,1,147873-1,
U1,CONV_LT8640SEV_PBF,1,LT8640SEV_PBF,C514429
U2,SOT-223-3_TabPin2,1,LT1963AEST-3.3#TRPBF,C459918
U3,IC_LM76202QPWPRQ1,1,LM76202QPWPRQ1,C1849484
U4,STM32U545CET6Q,1,STM32U545CET6Q,C20033864
U5,SOIC-8_3.9x4.9mm_P1.27mm,1,TJA1051T-3,C38695
U9,TLP291-4,1,TLP291-4GB-TP_E,C60900
X1,XS00A-CS07826,1,XS00A-CS07826,C7322371

## KiCad design Hardware/V2/displaycontrol.kicad_pcb

Board: 2 copper layers, 75.8 x 55.2 mm, 93 parts (0 on the bottom side), 68 nets.

Parts:
C1, C5, C6, C12, C13, C15, C16, C17, C20, C21, C23, C24, C25, C26, C27, C28, C29, C30, C31, C32: 100nF/16V/0603; C_0603_1608Metric
C2, C3: 8.28pF/16V/0603; C_0603_1608Metric
C4, C10, C14, C19: 1uF/16V/0603; C_0603_1608Metric
C7, C18: 10uF/16V/0805; C_0805_2012Metric
C8, C9: 2.2uF/16V/0603; C_0603_1608Metric
C11: 1uF/16V/0603; C_0805_2012Metric
C22: 4.7nF/16V/0603; C_0603_1608Metric
CR1: ESDALC6V1W5; SOT65P210X110-5N
D1, D2: ESDALC6V1-1U2; DIODE_ESDALC6V1-1U2
D3: SM1605E3; SOIC127P600X175-16N
D4, D5: LED; LED_0603_1608Metric
FB1: BLM18PG600SN1D; BLM18SP221SN1B
J1: STLINK; 20037WR-05
J3: FH34SRJ-10S-0.5SH_50_; HRS_FH34SRJ-10S-0.5SH_50_
J4: Conn_02x05_Odd_Even; PinHeader_2x05_P2.54mm_Vertical
L1: 2.2uH/1.5A/2016; INDC2016X100N
R1, R7, R8, R12, R13: 10K/1%/0603; R_0603_1608Metric
R2, R3: 47/1%/0603; R_0603_1608Metric
R4: 470/1%/0603; R_0603_1608Metric
R5: 910/1%/0603; R_0603_1608Metric
R6: 1K/1%/0603; R_0603_1608Metric
R9, R10, R14, R15, R19, R21, R23, R24, R27, R28, R31, R32: 4.7K/1%/0603; R_0603_1608Metric
R11, R35: 0/1%/0603; R_0603_1608Metric
R16, R17: 60/1%/0603; R_0603_1608Metric
R18: 10k/1%/0603; R_0603_1608Metric
R20, R22, R25, R26, R29, R30, R33, R34: 100/1%/0603; R_0603_1608Metric
R36, R37: 300/1%/0603; R_0603_1608Metric
SW1, SW2: SW_MEC_5E; SW_SPST_TL3342
U1: STM32U535CET6Q; LQFP48-7x7mm_STM
U2, U3, U6, U7: PC817; DIP-4_W7.62mm
U4: MR30
U5: wr_10p; 20037WR-10
U8: wr_03p; 20037WR-03
U9: TJA1051T-3; SOIC-8_3.9x4.9mm_P1.27mm
U10: wr_05p; 20037WR-06
X1: XS00A-CS07826

Connections:
+3V3: C6.1, C7.1, C12.1, C15.1, C16.1, C17.1, C18.1, C19.1, C20.1, J1.5, J3.6 (DISP), J4.2, J4.4, R7.2, R8.2, R12.2, R13.2, R19.2, R21.2, R23.2, R24.2, R27.2, R28.2, R31.2, R32.2, R35.1, SW2.1, U1.1 (VBAT), U1.21 (VDDSMPS), U1.25 (VDD), U1.36 (VDD), U1.48 (VDD), U4.2, U9.5 (VIO)
+5V: C10.1, C21.2, FB1.1, J3.3 (EXTMODE), J3.4 (VDD), U4.3, U9.3 (VCC)
+5VA: C11.1, FB1.2, J3.5 (VDDA)
/AIN0: R4.2, U10.6
/CANH: R16.2, U8.3, U9.7 (CANH)
/CANL: R17.2, U8.2, U9.6 (CANL)
/DIN0: R9.1, U10.1
/DIN1: R10.1, U10.2
/DIN2: R14.1, U10.3
/DIN3: R15.1, U10.4
/EXTCOMIN: J3.7 (EXTCOMIN), U1.14 (PA4)
/FDCAN1_RX: U1.32 (PA11), U9.4 (RXD)
/FDCAN1_TX: U1.33 (PA12), U9.1 (TXD)
/JTCK-SWCLK: R2.2, U1.37 (PA14)
/JTMS-SWDIO: R3.1, U1.34 (PA13)
/LED_ERR0: R36.1, U1.19 (PB1)
/LED_ERR1: R37.1, U1.18 (PB0)
/OSC_IN: C3.1, U1.5 (PH0-OSC_IN), X1.3
/OSC_OUT: C2.1, U1.6 (PH1-OSC_OUT), X1.1
/PA5: J4.9, U1.15 (PA5)
/PB3: J4.3, U1.39 (PB3)
/PB5: J4.1, U1.41 (PB5)
/PB6: J4.6, U1.42 (PB6)
/PB7: J4.5, U1.43 (PB7)
/PB8: J4.7, U1.45 (PB8)
/SCLK: J3.10 (SCLK), U1.11 (PA1)
/SCS: J3.8 (SCS), U1.16 (PA6)
/SI: J3.9 (SI), U1.17 (PA7)
/STM_AIN0: C4.1, R4.1, R5.2, U1.13 (PA3)
/STM_Button_0: C24.1, R19.1, R20.1, U1.27 (PB14)
/STM_Button_1: C25.1, R21.1, R22.1, U1.26 (PB13)
/STM_Button_2: C23.1, R27.1, R29.1, U1.38 (PA15)
/STM_Button_3: C26.1, R23.1, R25.1, U1.40 (PB4)
/STM_Button_4: C27.1, R24.1, R26.1, U1.31 (PA10)
/STM_Button_5: C29.1, R31.1, R33.1, U1.30 (PA9)
/STM_Button_6: C28.1, R28.1, R30.1, U1.29 (PA8)
/STM_Button_7: C30.1, R32.1, R34.1, U1.28 (PB15)
/STM_DIN0: R7.1, U1.10 (PA0), U2.4
/STM_DIN1: R8.1, U1.12 (PA2), U3.4
/STM_DIN2: R12.1, U1.3 (PC14-OSC32_IN), U6.4
/STM_DIN3: R13.1, U1.4 (PC15-OSC32_OUT), U7.4
/User Button: C5.1, D2.1, R6.2, SW2.2 (A), U1.2 (PC13)
/VDD11: C8.1, C9.1, C31.1, C32.2, L1.1, U1.23 (VDD11), U1.46 (VDD11)
/VDDA: C13.1, C14.1, R35.2, U1.9 (VDDA)
/VLXSMPS: L1.2, U1.20 (VLXSMPS)
/button_0: D3.1, R20.2, U5.3
/button_1: D3.2, R22.2, U5.4
/button_2: D3.3, R29.2, U5.5
/button_3: D3.4, R25.2, U5.6
/button_4: D3.5, R26.2, U5.7
/button_5: D3.6, R33.2, U5.8
/button_6: D3.7, R30.2, U5.9
/button_7: D3.8, R34.2, U5.10
GND: C1.2, C2.2, C3.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C12.2, C15.2, C16.2, C17.2, C18.2, C19.2, C20.2, C21.1, C22.1, C23.2, C24.2, C25.2, C26.2, C27.2, C28.2, C29.2, C30.2, C31.2, C32.1, CR1.2, D1.2, D2.2, D3.9, D3.10, D3.11, D3.12, D3.13, D3.14, D3.15, D3.16, D4.1 (K), D5.1 (K), J1.1, J3.2 (VSS), J4.8, J4.10, R1.2, R6.1, R11.1, R18.e, SW1.2 (A), U1.8 (VSSA), U1.22 (VSSSMPS), U1.24 (VSS), U1.35 (VSS), U1.47 (VSS), U2.3, U3.3, U4.1, U5.1, U5.2, U6.3, U7.3, U8.1, U9.ee (GND), X1.2 (GND), X1.4 (GND)
GNDA: C4.2, C11.2, C13.2, C14.2, J3.1 (VSSA), R5.1, R11.2
GND_EXT: U2.2, U3.2, U6.2, U7.2, U10.5
unnamed: C22.2, R16.1, R17.1
unnamed: D4.2 (A), R36.2
unnamed: D5.2 (A), R37.2
unnamed: CR1.1, J1.2, R3.2
unnamed: CR1.3, J1.3, R2.1
unnamed: R9.2, U2.1
unnamed: R10.2, U3.1
unnamed: R14.2, U6.1
unnamed: R15.2, U7.1
unnamed: R1.1, U1.44 (PH3-BOOT0)
unnamed: R18.2, U9.8 (S)
RESET: C1.1, D1.1, J1.4, SW1.1, U1.7 (NRST)

## Commit log (part)

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2026-05-11 26.05.11.
2026-05-15 committest
2026-05-15 26.05.13.
2026-05-15 26.05.15.
2026-05-19 26.05.19.
